# Keil uVision project TestProject.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: TestProject +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: -IF:/LouisSoftware/Keil5/ARM/RV31/INC
  c include: .\BSP;.\CMSIS;.\Drivers\inc;.\NUC1xx-LB_002\inc;.\OSEKos\inc;.\Ports\inc;.\Ports;.\RTE\_Target_1
  asm misc: -I F:\LouisSoftware\Keil5\ARM\RV31\INC
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
--libpath "F:\LouisSoftware\Keil5\ARM\ARMCC\lib"
  group CMSIS
    ./CMSIS/: core_cm0.c startup_NUC1xx.s system_NUC1xx.c
  group BSP
    ./BSP/: Init.c
  group Drivers
    ./Drivers/src/: DrvADC.c DrvCAN.c DrvEBI.c DrvFMC.c DrvGPIO.c DrvI2C.c DrvI2S.c DrvPDMA.c DrvPS2.c DrvPWM.c DrvRTC.c DrvSPI.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c
  group NUC1xx-LB_002
    ./NUC1xx-LB_002/src/: Ascii_Table.C EEPROM_24LC64.c LCD_Driver.c NAU7802.c ScanKey.c Seven_Segment.c
  group OSEKos
    ./OSEKos/: cfg.c osekAlarm.c osekCounter.c osekDebug.c osekEvent.c osekExecution.c osekHook.c osekInterrupt.c osekMessage.c osekResource.c osekTarget.c osekTask.c
  group Main
    ./Main/: main.c
  group OSEKinc
    ./OSEKos/inc/: cfg.h osapi.h osekAlarm.h osekCounter.h osekDebug.h osekEvent.h osekExecution.h osekHook.h osekInterrupt.h osekMessage.h osekOccConfig.h osekResource.h osekTarget.h osekTask.h osekTurboConfig.h osprop.h userMSG.h
